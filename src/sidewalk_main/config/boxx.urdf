Commit message: gridmap and segmentation adjusted

File: src/sidewalk_main/config/boxx.urdf (robot description, URDF)
Before this commit: robot boxx, 2 links, 1 joints
Links:
- removed link front_camera_link
Joints:
- removed joint front_camera_joint
